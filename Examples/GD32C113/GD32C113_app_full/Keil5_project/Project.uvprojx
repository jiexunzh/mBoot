# Keil uVision project Project.uvprojx, settings and files
target GD32C11X (6160000::V6.16::ARMCLANG)
  device: GD32C113CB GigaDevice
  pack: GigaDevice.GD32C11x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32C11X
  c include: ..\Libraries\CMSIS;..\Libraries\CMSIS\GD\GD32C11x\Include;..\Libraries\GD32C11x_standard_peripheral\Include;..\Bsp;..\App;..\uBoot\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ../App/: gd32c11x_it.c main.c mBoot_config.h
  group uBoot
    ../uBoot/Src/: mBoot_app.c
  group Bsp
    ../Bsp/: bsp_systick.c bsp_led.c bsp_rs485.c bsp_flash.c
  group Libraries
    ../Libraries/GD32C11x_standard_peripheral/Source/: gd32c11x_misc.c gd32c11x_rcu.c gd32c11x_gpio.c gd32c11x_usart.c gd32c11x_fmc.c
  group CMSIS
    ../Libraries/CMSIS/GD/GD32C11x/Source/: system_gd32c11x.c
    ../Libraries/CMSIS/GD/GD32C11x/Source/ARM/: startup_gd32c11x.s
